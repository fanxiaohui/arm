# Keil uVision project Project_GLCD_SPI_STM32F1.uvprojx, settings and files
target GLCD_SPI_GPHONE (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_GLCD_SPI_STM32F1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\FWLib\Include;.\Main;.\UserSTM32F1\Include;.\ProjectLib\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWLib
    ./FWLib/Source/: core_cm3.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c system_stm32f10x.c stm32f10x_flash.c
  group Main
    ./Main/: main.c
  group Project
    ./ProjectLib/source/: glcd_spi.c
  group UserSTM32F1
    ./UserSTM32F1/Source C/: user_delay.c user_gpio.c user_interrupt.c user_system.c
  group StartUp
    ./StartUp/arm/: startup_stm32f10x_md.s
