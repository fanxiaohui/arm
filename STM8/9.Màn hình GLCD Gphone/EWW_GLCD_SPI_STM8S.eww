<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project_GLCD_SPI_STM8S.ewp</path>
  </project>
  <batchBuild/>
</workspace>


