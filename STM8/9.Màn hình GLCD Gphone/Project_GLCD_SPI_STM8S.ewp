# IAR project Project_GLCD_SPI_STM8S.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; FWlib\include; User\include; main; ProjectLIB\include; UserSTM8\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Hex_GLCD_SPI_STM8S.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    FWLib/source/: stm8s_clk.c stm8s_gpio.c
  group Main
    Main/: main.c
  group Project
    ProjectLib/source/: glcd_spi.c
  group UserSTM8
    userSTM8/source/: clock.c delay.c gpio.c
